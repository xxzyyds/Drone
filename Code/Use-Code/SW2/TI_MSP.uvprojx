# Keil uVision project TI_MSP.uvprojx, settings and files
target ZKHD_MSP432_FMU (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ZKHD_MSP432_FMU +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4  __FPU_PRESENT __MSP432P401R__ TARGET_IS_MSP432P4XX keil
  c include: .\Connect;.\Control;.\DataBase;.\Driver;.\Driver\MSP432P4xx;.\main;.\Math;.\Sensor;.\GCS;.\Hardware;.\Config;.\Driver\MSP432P4xx
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group main
    ./main/: main.c MSP432_Interrupt.c
  group Hardware硬件程序
    ./Hardware/: hardware.c hardware.h motor.c HARDWARE_i2c.c HARDWARE_i2c.h HARDWARE_uart.c HARDWARE_uart.h timer_drv.c timer_drv.h Ano_OF.c Ano_OF.h eeprom.c power.c beep.c
    ./Control/: server.c
  group Config飞控配置
    ./Config/: fmuConfig.h
  group Sensor传感器数据获取
    ./Sensor/: battery.c battery.h LED.c LED.h mpu6050.c mpu6050.h SPL06.c SPL06.h
  group Math常用数学函数
    ./Math/: filter.c imu.c kalman.c myMath.c pid.c
  group DataBase构建的数据结构
    ./DataBase/: queue.c include.h queue.h
  group Control无人机控制器
    ./Control/: remote.c Init.c control.c height_control.c kernel.c speed_estimator.c pos_ctrl.c SDK.c FollowLine_eg3.c
  group GCS地面站处理程序
    ./GCS/: gcs.c Ano_DT.c
  group Connect地面站连接程序
    ./Connect/: ZKHD_Link.c
  group Driver官方驱动
    ./Driver/MSP432P4xx/: adc14.c adc14.h aes256.c aes256.h comp_e.c comp_e.h cpu.c cpu.h crc32.c crc32.h cs.c cs.h debug.h dma.c dma.h driverlib.h eusci.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h hw_memmap.h i2c.c i2c.h interrupt.c interrupt.h mpu.c mpu.h pcm.c pcm.h pmap.c pmap.h pss.c pss.h ref_a.c ref_a.h reset.c reset.h rom.h rom_map.h rtc_c.c rtc_c.h spi.c spi.h sysctl.c sysctl.h systick.c systick.h timer_a.c timer_a.h timer32.c timer32.h uart.c uart.h wdt_a.c wdt_a.h
    ./Driver/MSP432P4xx/keil/: msp432p4xx_driverlib.lib
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1, Device:Startup 3.2.2
